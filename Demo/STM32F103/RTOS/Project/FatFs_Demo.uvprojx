# Keil uVision project FatFs_Demo.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FatFs_Demo
  c flags: wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\STM32F10x_FWLib\inc;..\Drive;..\Drive\led;..\Drive\usart;..\System\sys;..\System\delay;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\Libraries\CMSIS\Include;..\FreeRTOS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\FatFs\Source;..\FatFs\FatFs_App;..\Drive\spi;..\Drive\flash
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group StarUp
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group STM32_LIB
    ../Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group FreeRTOS/Source
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group FatFs
    ../FatFs/Source/: ff.c diskio.c
    ../FatFs/Source/option/: ccsbcs.c
  group User
    ./: main.c
  group System
    ../System/sys/: sys.c
  group Drive
    ../Drive/: bsp_init.c
    ../Drive/usart/: bsp_usart.c
    ../Drive/led/: bsp_led.c
    ../Drive/spi/: bsp_spi.c
    ../Drive/flash/: bsp_flash.c
software components: CMSIS:CORE 4.3.0
